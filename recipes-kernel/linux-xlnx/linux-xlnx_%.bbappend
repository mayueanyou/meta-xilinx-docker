FILESEXTRAPATHS:prepend := "${THISDIR}/cfg:"
 
SRC_URI:append = " file://docker.cfg"
